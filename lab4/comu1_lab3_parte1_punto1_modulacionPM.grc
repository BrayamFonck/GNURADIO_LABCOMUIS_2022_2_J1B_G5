options:
  parameters:
    author: Brayan_Fonseca_J1B_G5
    copyright: Brayan_Fonseca_J1B_G5
    generate_options: qt_gui
    id: comu1_lab3_parte1_punto1_modulacionPM
    output_language: python
    title: comu1_lab3_parte1_punto1_modulacionPM
  states: {}

blocks:
- name: GTX
  id: variable_qtgui_range
  parameters:
    label: ganancia transmisor GTX
    start: '0'
    step: '1'
    stop: '30'
    value: '0'
  states: {}
- name: ac
  id: variable_qtgui_range
  parameters:
    label: amplitud portadora ac
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: am
  id: variable_qtgui_range
  parameters:
    label: amplitud mensaje am
    start: '0'
    step: '1e-6'
    stop: '1'
    value: '1'
  states: {}
- name: fc
  id: variable_qtgui_range
  parameters:
    label: frecuencia portadora fc
    start: 50e6
    step: 1e6
    stop: 2e9
    value: 50e6
  states: {}
- name: fm
  id: variable_qtgui_range
  parameters:
    label: Frecuencia mensaje fm
    start: '1000'
    step: '100'
    stop: '20000'
    value: '1000'
  states: {}
- name: kp
  id: variable_qtgui_range
  parameters:
    label: Coeficiente kp
    start: '0'
    step: '1e-6'
    stop: '10'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '200000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: am
    freq: fm
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: lab4_parte1_comu1_punto_1_envolcomplejapm_0
  id: lab4_parte1_comu1_punto_1_envolcomplejapm
  parameters:
    Ac: ac
    Kp: kp
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: fc
    gain0: GTX
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', lab4_parte1_comu1_punto_1_envolcomplejapm_0, '0']
- [lab4_parte1_comu1_punto_1_envolcomplejapm_0, '0', qtgui_freq_sink_x_0, '0']
- [lab4_parte1_comu1_punto_1_envolcomplejapm_0, '0', qtgui_time_sink_x_0, '0']
- [lab4_parte1_comu1_punto_1_envolcomplejapm_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
